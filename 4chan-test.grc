<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fourchanrx</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_1</value></param>
<param><key>value</key><value>14074000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_2</value></param>
<param><key>value</key><value>10136000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_3</value></param>
<param><key>value</key><value>18100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_4</value></param>
<param><key>value</key><value>21074000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>fifo_chan1.c2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>fifo_chan2.c2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>fifo_chan3.c2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_1</value></param>
<param><key>file</key><value>fifo_chan4.c2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq_1</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant1</key><value></value></param>
<param><key>center_freq1</key><value>freq_2</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>0</value></param>
<param><key>ant2</key><value></value></param>
<param><key>center_freq2</key><value>freq_3</value></param>
<param><key>dc_offs_enb2</key><value>""</value></param>
<param><key>iq_imbal_enb2</key><value>""</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>0</value></param>
<param><key>ant3</key><value></value></param>
<param><key>center_freq3</key><value>freq_4</value></param>
<param><key>dc_offs_enb3</key><value>""</value></param>
<param><key>iq_imbal_enb3</key><value>""</value></param>
<param><key>norm_gain3</key><value>False</value></param>
<param><key>gain3</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>"fpga=usrp1_fpga_4rx.rbf"</value></param>
<param><key>sd_spec0</key><value>A:A A:A A:A A:A</value></param>
<param><key>nchan</key><value>4</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>otw</key><value>sc16</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
</flow_graph>
